# Keil uVision project WirelessNode.uvproj, settings and files
target WirelessNode (ARM-ADS)
  device: STM32L151RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00014000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: WirelessNode +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xE
  c include: ..\HALLIB\Inc;..\USER;..\CMSIS;..\MAIN;..\USER\delay;..\USER\sys;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group MAIN
    ../MAIN/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c system_stm32l1xx.c
  group USER
    ../USER/delay/: delay.c
    ../USER/sys/: sys.c
  group CMSIC
    ../CORE/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group HALLIB
    ../HALLIB/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_gpio.c
  group START
    ../START/: startup_stm32l151xe.s
  group REDEME
    ../: readme.txt
  group FreeRTOS_CORE
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/portable/RVDS/ARM_CM3/: port.c
    ../FREERTOS/portable/MemMang/: heap_4.c
